## common/Kconfig
```kconfig
config DATE_CODE
	string "Zigbee firmware build date attribute"
	default "00000000"

source "Kconfig.zephyr"
```
